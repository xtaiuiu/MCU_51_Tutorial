# Keil uVision project LED_timer.uvproj, settings and files
target Target 1 (Error Demo) (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LED_timer +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group Error Demo
    ./: main.c
  group Source Group Correct Demo
    ./: main_correct.c main_inverse_example.c
target Target 2 (Correct Demo) (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LED_timer +hex
  c flags: Optimize=8 SizeSpeed=1
